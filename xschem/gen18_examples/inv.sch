** sch_path: xschem/gen18_examples/inv.sch
**.subckt inv
xM1 out in GND GND nmos18 w=0.5u l=0.18u m=1
M2 out in vdd vdd pmos18 w=1u l=0.18u m=1 ad='2*1u *0.18u' as='2*1u *0.18u' pd='2*(1u +2*0.18u)' ps='2*(1u +2*0.18u)'
V1 vdd GND 1.8
V2 in GND pwl 0 0 1n 0 {1n+10p} 1.8 2n 1.8 {2n+10p} 0
**** begin user architecture code

.include [xschem get current_dirname]/../../mdl/gen18.inc
.save all
.tran 10p 3n

**** end user architecture code
**.ends
.GLOBAL GND
.end
