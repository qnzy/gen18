** sch_path: xschem/gen18_examples/inv.sch
**.subckt inv
M1 out in GND GND nmos18 w=0.5u l=0.18u m=1 ad='2*0.5u *0.18u' as='2*0.5u *0.18u' pd='2*(0.5u +2*0.18u)'
+ ps='2*(0.5u +2*0.18u)'
M2 out in vdd vdd pmos18 w=1u l=0.18u m=1 ad='2*1u *0.18u' as='2*1u *0.18u' pd='2*(1u +2*0.18u)' ps='2*(1u +2*0.18u)'
V1 vdd GND 1.8
V2 in GND pwl 0 0 10n 0 {10n+10p} 1.8 20n 1.8 {20n+10p} 0
**** begin user architecture code

.include [xschem get current_dirname]/../../mdl/gen18.inc
.save all
.tran 10p 30n

**** end user architecture code
**.ends
.GLOBAL GND
.end
