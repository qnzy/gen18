** sch_path: xschem/gen18_examples/bg.sch
**.subckt bg
M1 nb nb net3 GND nmos18 w=2u l=2u m=1 ad='2*2u *0.18u' as='2*2u *0.18u' pd='2*(2u +2*0.18u)' ps='2*(2u +2*0.18u)'
M2 pb pb vdd vdd pmos18 w=1u l=2u m=1 ad='2*1u *0.18u' as='2*1u *0.18u' pd='2*(1u +2*0.18u)' ps='2*(1u +2*0.18u)'
V1 vdd GND 1.8
M3 nb pb vdd vdd pmos18 w=1u l=2u m=1 ad='2*1u *0.18u' as='2*1u *0.18u' pd='2*(1u +2*0.18u)' ps='2*(1u +2*0.18u)'
M4 pb nb net1 GND nmos18 w=2u l=2u m=1 ad='2*2u *0.18u' as='2*2u *0.18u' pd='2*(2u +2*0.18u)' ps='2*(2u +2*0.18u)'
Q1 GND GND net3 PNPS m=1
Q2 GND GND net2 PNPS m=8
R1 net1 net2 RPP W=1u L=300u m=1
M5 vbg pb vdd vdd pmos18 w=1u l=2u m=8 ad='2*1u *0.18u' as='2*1u *0.18u' pd='2*(1u +2*0.18u)' ps='2*(1u +2*0.18u)'
Q3 GND GND net4 PNPS m=1
R2 vbg net4 RPP W=1u L=355u m=1
**** begin user architecture code

.include [xschem get current_dirname]/../../mdl/gen18.inc
.probe i(r2)
.save all
.dc temp -40 150 10

**** end user architecture code
**.ends
.GLOBAL GND
.end
